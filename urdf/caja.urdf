Commit message: cambio de referencia imu_link a base_link

File: urdf/caja.urdf (robot description, URDF)
Before this commit: robot caja_imu, 1 links, 0 joints
Links:
- removed link imu_link
- added link base_link, mass 0.001; collision box size=1 1 1; visual box size=1 1 1
